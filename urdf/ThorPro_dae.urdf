Commit message: add urdf test file, fix few bus in urdf model

File: urdf/ThorPro_dae.urdf (robot description, URDF)
Before this commit: robot flexible, 2 links, 1 joints
Joints:
- joint joint_angle: origin xyz=0 0 0.3 -> xyz=0 0 0
